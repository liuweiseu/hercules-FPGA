# Keil uVision project top.uvproj, settings and files
target Target 1 (MCS-51)
  device: M5 HME
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: mipi_rx_pinf_tx_pinf_1080 +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_M5.A51 main.c
